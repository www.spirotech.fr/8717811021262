Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 6f0957dd-03e5-4dcf-9efe-4b98d1b06f86, NumberOfSaves: 0]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE300LM_INT-EN.ifc
Time: 2025-08-26T15:56:17+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_124183_1
Port_124183_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN:BE300LM, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN:BE300LM:124183
In: Level 1
Type - Material: Color RGB 198-000-000, Color RAL 1003, Color RGB 040-040-040, Color RGB 168-128-048, Color RGB 128-128-128
Type - Other - Category: Pipe Accessories; Base Flange: 15.5 mm; Base Flange Radius: 161.95 mm; Bottom Geomtry Height: 155 mm; Brackets Height: 34 mm; Brackets Height 2: 35 mm; Chamfer Radius: 101.5 mm; Cone Flange: 34 mm; Cone Flange Radius Bottom: 181 mm; Cone Flange Radius Top: 161.95 mm; Connection Diameter: 0.00328084 mm; Cylinder Height: 18.5 mm; Distance Between Brackets: 408 mm; DN: 0.00328084 mm; Drain Offset: 88.39 mm; Drain Radius: 30.15 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN; Flange Body: 24 mm; Flange Body Radius: 230 mm; Flange Gasket: 4 mm; Flange Gasket Radius: 189 mm; Front Bracket Height: 105 mm; Front Bracket Offset: 600 mm; Front Bracket Offset 2: 305 mm; h1: 426 mm; Height: 1452.5 mm; Hexagon Height: 5 mm; Inner Diameter Ring: 10 mm; OD: 323.8 mm; Outer Diameter Ring: 60 mm; Total Length Drain: 74.51 mm; Type Value: 17; Upper Geometry Radius: 12 mm; Upper Side Height: 407 mm; Width: 750 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 610 mm; H: 1435 mm; L: 850 mm; LF: 1005 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Particle and dirt separator - Steel - Magnet - Weld DN300; Article Type: BE300LM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Steel - Magnet - Weld DN300; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811040317; Manufacturer: Spirotech; Manufacturer Art. No.: BE300LM; Manufacturer URL: https://www.spirotech.com/8717811040317; MEPcontent Class: SEPARATOR_DIRT; Model: BE300LM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BE300LM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 dm3/s; Nominal Flow Rate: 112.5 dm3/s; Pressure Stage: 0; Volume: 0.35 m3; Weight: 261 kg
Type - Mechanical - Flow - Pressure Drop: 7.8 Pa
Type - Text - Pipe Type Category: M561
Type - Visibility - Drain Visibility: yes; Flange: no; Front Bracket: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BE300LM; sets with these values: 2
Other - Bottom Clearance Safe: 900 mm; Connection Length: 850 mm; Connectors Length: 1004 mm; Connectors Length Safe: 985 mm; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN: BE300LM; Length: 850 mm; Top Clearance Safe: 50 mm; Type: BE300LM; Type Id: 124168
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 4.4535 m2; Maximum Size: 0.00328084 mm; Minimum Size: 0.00328084 mm; Volume: 0.402318 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 1
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 dm3/s
Phasing - Phase Created: New Construction
Visibility - Bottom Clearance: 900 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
