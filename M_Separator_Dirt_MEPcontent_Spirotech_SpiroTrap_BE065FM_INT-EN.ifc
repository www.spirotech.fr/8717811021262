Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE065FM_INT-EN.ifc
Time: 2025-08-05T18:35:33+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2184983_1
Port_2184983_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN:BE065FM, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN:BE065FM:2184983
In: F00
Type - Material: Color RGB 198-000-000, Color RAL 1003, Color RGB 040-040-040, Color RGB 168-128-048, Color RGB 128-128-128
Type - Other - Category: Pipe Accessories; Base Flange: 10 mm; Base Flange Radius: 38.05 mm; Bottom Geomtry Height: 95 mm; Brackets Height: 6 mm; Brackets Height 2: 16 mm; Chamfer Radius: 35 mm; Cone Flange: 17 mm; Cone Flange Radius Bottom: 49 mm; Cone Flange Radius Top: 38.05 mm; Connection Diameter: 65 mm; Cylinder Height: 6.8 mm; Distance Between Brackets: 137 mm; DN: 65 mm; Drain Offset: 0 mm; Drain Radius: 16.85 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN; Flange Body: 15 mm; Flange Body Radius: 92.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 61 mm; Front Bracket Height: 60.0027 mm; Front Bracket Offset: 184.003 mm; Front Bracket Offset 2: 79.5 mm; h1: 129 mm; Height: 415.5 mm; Hexagon Height: 3.7 mm; Inner Diameter Ring: 6 mm; OD: 76.1 mm; Outer Diameter Ring: 26 mm; Total Length Drain: 48.81 mm; Type Value: 4; Upper Geometry Radius: 12 mm; Upper Side Height: 120 mm; Width: 233 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 159 mm; H: 405 mm; L: 260 mm; LF: 350 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Particle and dirt separator - Steel - Magnet - Flange DN065; Article Type: BE065FM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Steel - Magnet - Flange DN065; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811021569; Manufacturer: Spirotech; Manufacturer Art. No.: BE065FM; Manufacturer URL: https://www.spirotech.com/8717811021569; MEPcontent Class: SEPARATOR_DIRT; Model: BE065FM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BE065FM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.00556 m3/s; Pressure Stage: 16; Volume: 0.005 m3; Weight: 14 kg
Type - Mechanical - Flow - Pressure Drop: 2.9 Pa
Type - Visibility - Drain Visibility: no; Flange: yes; Front Bracket: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BE065FM; sets with these values: 2
Other - Bottom Clearance Safe: 330 mm; Connection Length: 350 mm; Connectors Length: 350 mm; Connectors Length Safe: 395 mm; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_BE_INT-EN: BE065FM; Length: 350 mm; Top Clearance Safe: 50 mm; Type: BE065FM; Type Id: 2184948
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.539205 m2; Maximum Size: 65 mm; Minimum Size: 65 mm; Volume: 0.0100409 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 330 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
